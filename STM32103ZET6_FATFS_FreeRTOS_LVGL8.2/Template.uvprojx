# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=188  --diag_suppress=223  --diag_suppress=546  --diag_suppress=1295
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\Malloc;.\Font;.\Drive\flash;.\Drive\key;.\Drive\led;.\Drive\sd_sdio;.\Drive\spi;.\Drive\tftlcd;.\Middlewares\Fatfs\fatfs_app;.\Middlewares\Fatfs\src;.\Drive\24Cxx;.\Drive\iic;.\Drive\touch;.\Drive\sram;.\Drive\lcd;.\Middlewares\RTOS\FreeRTOS\freertos\include;.\Middlewares\RTOS\FreeRTOS\freertos\portable\RVDS\ARM_CM3;.\Middlewares\RTOS\FreeRTOS_APP;.\Drive\time;.\Middlewares\GUI\LVGL;.\Middlewares\GUI\LVGL\lvgl;.\Middlewares\GUI\LVGL\lvgl\src;.\Middlewares\GUI\LVGL\lvgl\examples\porting;.\Middlewares\GUI\LVGL_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Drive
    ./Drive/flash/: flash.c
    ./Drive/key/: key.c
    ./Drive/led/: led.c
    ./Drive/sd_sdio/: sd_sdio.c
    ./Drive/spi/: spi.c
    ./Drive/tftlcd/: tftlcd.c
    ./Drive/24Cxx/: 24cxx.c
    ./Drive/iic/: iic.c
    ./Drive/touch/: ctiic.c gt5663.c touch.c
    ./Drive/sram/: sram.c
    ./Drive/time/: time.c
    ./Drive/lcd/: cst816t.c i2c.c st7789v.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
  group Font
    ./Font/: font_show.c font_update.c
  group Fatfs
    ./Middlewares/Fatfs/src/: diskio.c ff.c
    ./Middlewares/Fatfs/fatfs_app/: fatfs_app.c mycc936.c
  group FreeRTOS_core
    ./Middlewares/RTOS/FreeRTOS/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_ports
    ./Middlewares/RTOS/FreeRTOS/freertos/portable/MemMang/: heap_4.c
    ./Middlewares/RTOS/FreeRTOS/freertos/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_app
    ./Middlewares/RTOS/FreeRTOS_APP/: FreeRTOS_text.c
  group LVGL_ports
    ./Middlewares/GUI/LVGL/lvgl/examples/porting/: lv_port_indev_template.c lv_port_disp_template.c
  group LVGL_core
    ./Middlewares/GUI/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_draw
    ./Middlewares/GUI/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Middlewares/GUI/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
  group LVGL_extra
    ./Middlewares/GUI/LVGL/lvgl/src/extra/: lv_extra.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./Middlewares/GUI/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
  group LVGL_font
    ./Middlewares/GUI/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL_gpu
    ./Middlewares/GUI/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./Middlewares/GUI/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL_hal
    ./Middlewares/GUI/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_misc
    ./Middlewares/GUI/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_widget
    ./Middlewares/GUI/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_app
    ./Middlewares/GUI/LVGL_APP/: text.c
